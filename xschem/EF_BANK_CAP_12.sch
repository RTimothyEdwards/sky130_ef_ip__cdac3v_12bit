v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/lab_pin.sym} 1095 -860 0 0 {name=p1 sig_type=std_logic lab=D0}
C {devices/lab_pin.sym} 1095 -780 0 0 {name=p2 sig_type=std_logic lab=D4}
C {devices/lab_pin.sym} 1095 -900 0 0 {name=p3 sig_type=std_logic lab=VP1}
C {devices/lab_pin.sym} 1095 -840 0 0 {name=p4 sig_type=std_logic lab=D1}
C {devices/lab_pin.sym} 1095 -820 0 0 {name=p5 sig_type=std_logic lab=D2}
C {devices/lab_pin.sym} 1095 -880 0 0 {name=p7 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1095 -800 0 0 {name=p9 sig_type=std_logic lab=D3}
C {devices/lab_pin.sym} 1095 -530 0 0 {name=p10 sig_type=std_logic lab=D8}
C {devices/lab_pin.sym} 1095 -760 0 0 {name=p12 sig_type=std_logic lab=D5}
C {devices/lab_pin.sym} 1095 -510 0 0 {name=p13 sig_type=std_logic lab=D9}
C {devices/lab_pin.sym} 1095 -610 0 0 {name=p14 sig_type=std_logic lab=VP2}
C {devices/lab_pin.sym} 1095 -570 0 0 {name=p15 sig_type=std_logic lab=D6}
C {devices/lab_pin.sym} 1095 -590 0 0 {name=p16 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1095 -550 0 0 {name=p17 sig_type=std_logic lab=D7}
C {devices/lab_pin.sym} 1095 -710 0 0 {name=p18 sig_type=std_logic lab=VP1}
C {devices/lab_pin.sym} 1095 -690 0 0 {name=p29 sig_type=std_logic lab=VP2}
C {devices/lab_pin.sym} 1095 -670 0 0 {name=p30 sig_type=std_logic lab=VSS}
C {EF_LSB_CAP.sym} 1245 -840 0 0 {name=x4}
C {EF_MSB_CAP.sym} 1245 -550 0 0 {name=x1}
C {EF_SC_CAP.sym} 1245 -690 0 0 {name=x2}
C {devices/iopin.sym} 790 -820 0 1 {name=p31 lab=D0}
C {devices/iopin.sym} 790 -800 0 1 {name=p32 lab=D1}
C {devices/iopin.sym} 790 -780 0 1 {name=p33 lab=D2}
C {devices/iopin.sym} 790 -760 0 1 {name=p34 lab=D3}
C {devices/iopin.sym} 790 -740 0 1 {name=p35 lab=D4}
C {devices/iopin.sym} 790 -720 0 1 {name=p36 lab=D5}
C {devices/iopin.sym} 790 -700 0 1 {name=p37 lab=D6}
C {devices/iopin.sym} 790 -680 0 1 {name=p38 lab=D7}
C {devices/iopin.sym} 790 -660 0 1 {name=p39 lab=D8}
C {devices/iopin.sym} 790 -640 0 1 {name=p40 lab=D9}
C {devices/iopin.sym} 790 -560 0 1 {name=p19 lab=VSS}
C {devices/iopin.sym} 790 -870 0 1 {name=p20 lab=VP1}
C {devices/iopin.sym} 790 -890 0 1 {name=p21 lab=VP2}
C {devices/iopin.sym} 790 -620 0 1 {name=p6 lab=D10}
C {devices/iopin.sym} 790 -600 0 1 {name=p8 lab=D11}
C {devices/lab_pin.sym} 1095 -490 0 0 {name=p11 sig_type=std_logic lab=D10}
C {devices/lab_pin.sym} 1095 -470 0 0 {name=p22 sig_type=std_logic lab=D11}
C {devices/iopin.sym} 790 -910 0 1 {name=p23 lab=Vref}
C {lab_pin.sym} 1095 -920 0 0 {name=p24 sig_type=std_logic lab=Vref}
