v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/lab_pin.sym} -310 -1480 0 0 {name=p2 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} -310 -1440 0 0 {name=p3 sig_type=std_logic lab=D0}
C {devices/lab_pin.sym} -310 -1360 0 0 {name=p4 sig_type=std_logic lab=D4}
C {devices/lab_pin.sym} -310 -1280 0 0 {name=p5 sig_type=std_logic lab=D8}
C {devices/lab_pin.sym} -310 -1260 0 0 {name=p7 sig_type=std_logic lab=D9}
C {devices/lab_pin.sym} -310 -1340 0 0 {name=p9 sig_type=std_logic lab=D5}
C {devices/lab_pin.sym} -310 -1420 0 0 {name=p10 sig_type=std_logic lab=D1}
C {devices/lab_pin.sym} -310 -1400 0 0 {name=p47 sig_type=std_logic lab=D2}
C {devices/lab_pin.sym} -310 -1320 0 0 {name=p48 sig_type=std_logic lab=D6}
C {devices/lab_pin.sym} -310 -1460 0 0 {name=p71 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -310 -1300 0 0 {name=p72 sig_type=std_logic lab=D7}
C {devices/lab_pin.sym} -310 -1380 0 0 {name=p81 sig_type=std_logic lab=D3}
C {devices/lab_pin.sym} -310 -1500 0 0 {name=p1 sig_type=std_logic lab=OUTNC}
C {devices/lab_pin.sym} 180 -980 2 1 {name=p6 sig_type=std_logic lab=SELD5}
C {devices/lab_pin.sym} 180 -960 2 1 {name=p8 sig_type=std_logic lab=SELD4}
C {devices/lab_pin.sym} 180 -940 2 1 {name=p11 sig_type=std_logic lab=SELD3}
C {devices/lab_pin.sym} 180 -1000 2 1 {name=p12 sig_type=std_logic lab=SELD6}
C {devices/lab_pin.sym} 180 -1020 2 1 {name=p13 sig_type=std_logic lab=SELD7}
C {devices/lab_pin.sym} 180 -920 2 1 {name=p14 sig_type=std_logic lab=SELD2}
C {devices/lab_pin.sym} 180 -1040 2 1 {name=p15 sig_type=std_logic lab=SELD8}
C {devices/lab_pin.sym} 180 -880 2 1 {name=p16 sig_type=std_logic lab=SELD0}
C {devices/lab_pin.sym} 180 -900 2 1 {name=p17 sig_type=std_logic lab=SELD1}
C {devices/lab_pin.sym} 180 -1060 0 0 {name=p18 sig_type=std_logic lab=SELD9}
C {devices/lab_pin.sym} -310 -900 0 0 {name=p19 sig_type=std_logic lab=D0}
C {devices/lab_pin.sym} -310 -880 0 0 {name=p20 sig_type=std_logic lab=D1}
C {devices/lab_pin.sym} -310 -860 0 0 {name=p21 sig_type=std_logic lab=D2}
C {devices/lab_pin.sym} -310 -840 0 0 {name=p22 sig_type=std_logic lab=D3}
C {devices/lab_pin.sym} -310 -820 0 0 {name=p23 sig_type=std_logic lab=D4}
C {devices/lab_pin.sym} -310 -800 0 0 {name=p24 sig_type=std_logic lab=D5}
C {devices/lab_pin.sym} -310 -780 0 0 {name=p25 sig_type=std_logic lab=D6}
C {devices/lab_pin.sym} -310 -760 0 0 {name=p26 sig_type=std_logic lab=D7}
C {devices/lab_pin.sym} -310 -740 0 0 {name=p27 sig_type=std_logic lab=D8}
C {devices/lab_pin.sym} -310 -720 0 0 {name=p28 sig_type=std_logic lab=D9}
C {devices/lab_pin.sym} -10 -1140 0 1 {name=p29 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -10 -1080 0 1 {name=p54 sig_type=std_logic lab=DVSS}
C {devices/lab_pin.sym} -10 -1060 0 1 {name=p55 sig_type=std_logic lab=VH}
C {devices/lab_pin.sym} -10 -1040 0 1 {name=p56 sig_type=std_logic lab=VL}
C {devices/lab_pin.sym} 170 -1395 0 0 {name=p57 sig_type=std_logic lab=OUTNC}
C {devices/lab_pin.sym} 170 -1375 0 0 {name=p58 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 470 -1395 0 1 {name=p59 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 470 -1355 0 1 {name=p63 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 470 -1335 0 1 {name=p64 sig_type=std_logic lab=hold_3v3}
C {EF_BANK_CAP_12.sym} -160 -1380 0 0 {name=x4}
C {EF_AMUX0201_ARRAY1.sym} -160 -950 0 0 {name=x3}
C {EF_SW_RST.sym} 320 -1365 0 0 {name=x1}
C {devices/ipin.sym} -495 -1520 0 0 {name=p61 lab=SELD0}
C {devices/ipin.sym} -495 -1500 0 0 {name=p30 lab=SELD1}
C {devices/ipin.sym} -495 -1480 0 0 {name=p31 lab=SELD2}
C {devices/ipin.sym} -495 -1460 0 0 {name=p32 lab=SELD3}
C {devices/ipin.sym} -495 -1440 0 0 {name=p65 lab=SELD4}
C {devices/ipin.sym} -495 -1420 0 0 {name=p66 lab=SELD5}
C {devices/ipin.sym} -495 -1400 0 0 {name=p67 lab=SELD6}
C {devices/ipin.sym} -495 -1380 0 0 {name=p68 lab=SELD7}
C {devices/ipin.sym} -495 -1360 0 0 {name=p69 lab=SELD8}
C {devices/ipin.sym} -495 -1340 0 0 {name=p70 lab=SELD9}
C {devices/iopin.sym} -570 -1255 0 0 {name=p33 lab=VDD}
C {devices/iopin.sym} -570 -1195 0 0 {name=p34 lab=DVDD}
C {devices/iopin.sym} -570 -1165 0 0 {name=p35 lab=DVSS}
C {devices/iopin.sym} -570 -1135 0 0 {name=p41 lab=VH}
C {devices/iopin.sym} -570 -1105 0 0 {name=p42 lab=VL}
C {devices/iopin.sym} -570 -1225 0 0 {name=p43 lab=VSS}
C {devices/ipin.sym} -545 -970 0 0 {name=p46 lab=RST}
C {devices/lab_pin.sym} -10 -1120 0 1 {name=p44 sig_type=std_logic lab=VSS}
C {devices/opin.sym} -560 -910 0 0 {name=p39 lab=OUT}
C {devices/opin.sym} -560 -860 0 0 {name=p40 lab=OUTNC}
C {devices/ipin.sym} -495 -1320 0 0 {name=p37 lab=SELD10}
C {devices/ipin.sym} -495 -1300 0 0 {name=p52 lab=SELD11}
C {devices/lab_pin.sym} -310 -1240 0 0 {name=p53 sig_type=std_logic lab=D10}
C {devices/lab_pin.sym} -310 -1220 0 0 {name=p60 sig_type=std_logic lab=D11}
C {devices/lab_pin.sym} 180 -1080 0 0 {name=p73 sig_type=std_logic lab=SELD10}
C {devices/lab_pin.sym} 180 -1100 0 0 {name=p74 sig_type=std_logic lab=SELD11}
C {devices/lab_pin.sym} -310 -700 0 0 {name=p75 sig_type=std_logic lab=D10}
C {devices/lab_pin.sym} -310 -680 0 0 {name=p76 sig_type=std_logic lab=D11}
C {devices/iopin.sym} -570 -1045 0 0 {name=p38 lab=VIN}
C {devices/lab_pin.sym} 170 -1355 0 0 {name=p45 sig_type=std_logic lab=VIN}
C {devices/iopin.sym} -570 -1015 0 0 {name=p50 lab=Vref}
C {devices/iopin.sym} -570 -1075 0 0 {name=p51 lab=VCM}
C {devices/lab_pin.sym} -10 -1020 0 1 {name=p77 sig_type=std_logic lab=VCM}
C {devices/lab_pin.sym} -310 -1520 0 0 {name=p78 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} -310 -660 0 0 {name=p79 sig_type=std_logic lab=rst_3v3}
C {devices/ipin.sym} -545 -940 0 0 {name=p80 lab=HOLD}
C {cdac_lvlshift_array.sym} 330 -940 0 0 {name=x2}
C {devices/lab_pin.sym} 180 -840 0 0 {name=p82 sig_type=std_logic lab=HOLD}
C {devices/lab_pin.sym} 180 -860 0 0 {name=p83 sig_type=std_logic lab=RST}
C {devices/lab_pin.sym} 480 -760 0 1 {name=p84 sig_type=std_logic lab=DVSS}
C {devices/lab_pin.sym} 480 -780 0 1 {name=p85 sig_type=std_logic lab=DVDD}
C {devices/lab_pin.sym} 480 -800 0 1 {name=p86 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 480 -860 0 1 {name=p87 sig_type=std_logic lab=rst_3v3}
C {devices/lab_pin.sym} 480 -840 0 1 {name=p88 sig_type=std_logic lab=hold_3v3}
C {devices/lab_pin.sym} 480 -880 0 1 {name=p89 sig_type=std_logic lab=sel0_3v3}
C {devices/lab_pin.sym} 480 -900 0 1 {name=p90 sig_type=std_logic lab=sel1_3v3}
C {devices/lab_pin.sym} 480 -920 0 1 {name=p91 sig_type=std_logic lab=sel2_3v3}
C {devices/lab_pin.sym} 480 -940 0 1 {name=p92 sig_type=std_logic lab=sel3_3v3}
C {devices/lab_pin.sym} 480 -960 0 1 {name=p93 sig_type=std_logic lab=sel4_3v3}
C {devices/lab_pin.sym} 480 -980 0 1 {name=p94 sig_type=std_logic lab=sel5_3v3}
C {devices/lab_pin.sym} 480 -1000 0 1 {name=p95 sig_type=std_logic lab=sel6_3v3}
C {devices/lab_pin.sym} 480 -1020 0 1 {name=p96 sig_type=std_logic lab=sel7_3v3}
C {devices/lab_pin.sym} 480 -1040 0 1 {name=p97 sig_type=std_logic lab=sel8_3v3}
C {devices/lab_pin.sym} 480 -1060 0 1 {name=p98 sig_type=std_logic lab=sel9_3v3}
C {devices/lab_pin.sym} 480 -1080 0 1 {name=p99 sig_type=std_logic lab=sel10_3v3}
C {devices/lab_pin.sym} 480 -1100 0 1 {name=p100 sig_type=std_logic lab=sel11_3v3}
C {devices/lab_pin.sym} -310 -1140 0 0 {name=p101 sig_type=std_logic lab=sel0_3v3}
C {devices/lab_pin.sym} -310 -1120 0 0 {name=p102 sig_type=std_logic lab=sel1_3v3}
C {devices/lab_pin.sym} -310 -1100 0 0 {name=p103 sig_type=std_logic lab=sel2_3v3}
C {devices/lab_pin.sym} -310 -1080 0 0 {name=p104 sig_type=std_logic lab=sel3_3v3}
C {devices/lab_pin.sym} -310 -1060 0 0 {name=p105 sig_type=std_logic lab=sel4_3v3}
C {devices/lab_pin.sym} -310 -1040 0 0 {name=p106 sig_type=std_logic lab=sel5_3v3}
C {devices/lab_pin.sym} -310 -1020 0 0 {name=p107 sig_type=std_logic lab=sel6_3v3}
C {devices/lab_pin.sym} -310 -1000 0 0 {name=p108 sig_type=std_logic lab=sel7_3v3}
C {devices/lab_pin.sym} -310 -980 0 0 {name=p109 sig_type=std_logic lab=sel8_3v3}
C {devices/lab_pin.sym} -310 -960 0 0 {name=p110 sig_type=std_logic lab=sel9_3v3}
C {devices/lab_pin.sym} -310 -940 0 0 {name=p111 sig_type=std_logic lab=sel10_3v3}
C {devices/lab_pin.sym} -310 -920 0 0 {name=p112 sig_type=std_logic lab=sel11_3v3}
C {devices/lab_pin.sym} 470 -1375 0 1 {name=p36 sig_type=std_logic lab=DVSS}
C {devices/lab_pin.sym} 470 -1315 0 1 {name=p49 sig_type=std_logic lab=holdb_3v3}
C {devices/lab_pin.sym} 480 -820 0 1 {name=p62 sig_type=std_logic lab=holdb_3v3}
